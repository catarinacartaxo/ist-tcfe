R1 1 2 1.02043025561k
R2 3 2 2.0041718511k
R3 2 5 3.090579259k
R4 5 GND 4.00562948037k
R5 5 6 3.03133870093k
R6 9 7 2.06427287006k
R7 7 8 1.04245638189k
Vim 9 GND 0V
GIb 6 3 (2 5) 7.11526378475mS
HVd 5 8 Vim 8.01207369538kOhm
